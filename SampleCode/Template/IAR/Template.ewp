# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC029AE series Nuvoton NUC029AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\NUC029FAE\Include; ..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: Template.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC029FAE/Source/IAR/: startup_NUC029FAE.s
    ../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c
  group User
    ../: main.c
