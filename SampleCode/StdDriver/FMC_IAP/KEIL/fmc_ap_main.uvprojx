# Keil uVision project fmc_ap_main.uvprojx, settings and files
target APROM_code (6190000::V6.19::ARMCLANG)
  device: NUC029FAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: APROM_code
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_NUC029FAE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/ARM/: startup_NUC029FAE.s
  group User
    ../: APROM_main.c
    ./: ap_image.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c fmc.c clk.c
