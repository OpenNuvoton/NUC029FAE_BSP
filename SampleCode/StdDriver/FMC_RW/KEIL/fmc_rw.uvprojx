# Keil uVision project fmc_rw.uvprojx, settings and files
target fmc_rw (6150000::V6.15::ARMCLANG)
  device: NUC029FAE Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: fmc_rw
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_NUC029FAE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/ARM/: startup_NUC029FAE.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c fmc.c clk.c
