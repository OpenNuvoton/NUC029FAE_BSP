# Keil uVision project SPI_Loopback.uvprojx, settings and files
target SPI_Loopback (6120000::V6.12::.\ARMCLANG)
  device: NUC029FAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/ARM/: startup_NUC029FAE.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c spi.c
