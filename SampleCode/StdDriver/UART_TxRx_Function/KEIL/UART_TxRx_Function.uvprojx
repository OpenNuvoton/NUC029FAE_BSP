# Keil uVision project UART_TxRx_Function.uvprojx, settings and files
target UART_TxRx_Function (6150000::V6.15::ARMCLANG)
  device: NUC029FAE Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include;..\..\..\..\Library\StdDriver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  link misc: --map --first='startup_NUC029FAE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/ARM/: startup_NUC029FAE.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c sys.c
  group User
    ../: main.c
