# Keil uVision project I2C_Interrupt_EEPROM.uvprojx, settings and files
target I2C_Interrupt_EEPROM (6190000::V6.19::ARMCLANG)
  device: NUC029FAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/ARM/: startup_NUC029FAE.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c sys.c uart.c retarget.c
