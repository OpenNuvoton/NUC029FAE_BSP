# Keil uVision project ISP_UART.uvprojx, settings and files
target ISP_UART (6190000::V6.19::ARMCLANG)
  device: NUC029FAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: NUC029FAE_ISP_UART0_P12_P13
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include;..\..\..\..\Library\StdDriver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  link misc: --map --first='startup_NUC029FAE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/ARM/: startup_NUC029FAE.s
  group User
    ../: main.c FMC_USER.c ISP_USER.c uart_transfer.c targetdev.c
